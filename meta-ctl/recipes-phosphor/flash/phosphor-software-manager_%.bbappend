FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Added-OTP-and-ROT-Image-type-support-for-BMC-Firmware.patch \
    "

