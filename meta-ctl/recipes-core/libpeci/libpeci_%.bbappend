FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " \
        file://0001-CTL-Add-rpl-and-adl-to-supported-CPU-model.patch \
"
