# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/phosphor-post-code-manager.git;branch=master;protocol=https"
SRCREV = "a4c19b0032900982b4e8ae85791f4dbd498457a8"
