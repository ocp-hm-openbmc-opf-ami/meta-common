# Enable downstream autobump
# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/phosphor-sel-logger.git;branch=master;protocol=https"
SRCREV = "56ccc249f3f45bcb7486c93a19ab271173c64c68"

