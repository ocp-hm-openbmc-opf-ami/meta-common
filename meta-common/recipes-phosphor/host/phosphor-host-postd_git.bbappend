DEPENDS += " gtest"

# The URI is required for the autobump script but keep it commented
# to not override the upstream value
#SRC_URI = "git://github.com/openbmc/phosphor-host-postd.git;branch=master;protocol=https"
SRCREV = "b987663f44c166f42c1b02291b57341ba7c0c0d9"
