SRC_URI = "git://git@github.com/intel-collab/firmware.bmc.openbmc.applications.whitley-webui.git;protocol=ssh;branch=intel2"
FILESEXTRAPATHS:prepend:intel := "${THISDIR}/${PN}:"

SRCREV = "b5707d7648de19350b3f308b9602c888c6418d6f"
