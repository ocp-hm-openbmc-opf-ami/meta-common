FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/obmc-ikvm;branch=master;protocol=https"
SRCREV = "3c110335bd170a4b5ae6c591d3201c1ab7b03b00"
